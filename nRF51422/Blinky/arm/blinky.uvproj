# Keil uVision project blinky.uvproj, settings and files
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: blinky_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_ANT_IO SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: ..\..\Include;..\..\Include\app_common;..\..\Include\s210;..\..\Include\sdk_soc;..\..\Include\sd_common;..\..\Include\serialization\common;..\Spansion_SLLD_v13.2.1\Hals\nRF51xxx;..\Spansion_SLLD_v13.2.1\src;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group app
    ../: main.c FlashApp.c
    ../../Source/: keil_arm_uv4.lnt
  group core
    ../../Source/templates/arm/: arm_startup_nrf51.s
    ../../Source/templates/: system_nrf51.c
  group lib
    ../../Source/spi_master/: spi_master.c
    ../Spansion_SLLD_v13.2.1/src/: slld.c
    ../Spansion_SLLD_v13.2.1/Hals/nRF51xxx/: slld_hal.c
    ../../Source/nrf_delay/: nrf_delay.c
    ../../Source/app_common/: app_timer.c
