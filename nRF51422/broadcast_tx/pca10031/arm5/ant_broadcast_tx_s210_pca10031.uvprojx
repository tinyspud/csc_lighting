# Keil uVision project ant_broadcast_tx_s210_pca10031.uvprojx, settings and files
target nrf51422_xxAA (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxAA_S210 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 ANT_STACK_SUPPORT_REQD S210 SOFTDEVICE_PRESENT BOARD_CUSTOM SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: ..\..\..\uv5_Include;..\..\..\..\nRF51422;..\..\..\Spansion_SLLD_v13.2.1\Hals\nRF51xxx;..\..\..\Spansion_SLLD_v13.2.1\src
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x3700
  scatter file: .\_build\nrf51422_xxac.sct
  group Application
    ../../: main.c
    ../../../: FlashApp.c LEDs.c S210_LL.c system_error_callbacks.c system_ADC_LL.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Flash
    ../../../Spansion_SLLD_v13.2.1/src/: slld.c
    ../../../Spansion_SLLD_v13.2.1/Hals/nRF51xxx/: slld_hal.c
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAA/: bsp.c
  group ::Device
    RTE/Device/nRF51422_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAA/: spi_master.c spi_master.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAA/: app_button.c app_button.h app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h
software components: CMSIS:CORE , Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:nrf_soc 1.2.0, nRF_Drivers:nrf_temp 1.2.0, nRF_Drivers:spi_master 1.2.0, nRF_Libraries:app_button 1.1.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s210 4.0.1-3
